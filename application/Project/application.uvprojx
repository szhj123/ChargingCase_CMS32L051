# Keil uVision project application.uvprojx, settings and files
target application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32L051LQ32 Cmsemicon
  pack: Cmsemicon.CMS32L051.1.2.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\CMSIS\Include;..\..\Device\Include;..\..\Device\Source;..\..\Driver\inc;..\User\App;..\User\Drv;..\User\Hal
  memory RVCT4: ROM 0x1800 size 0xe800
  memory RVCT9: RAM 0x20000100 size 0xf00
  group Startup
    ../../Device/Source/ARM/: startup_CMS32L051.s
  group Cmsis
    ../User/Hal/: system_CMS32L051.c
  group Library
    ../../Driver/src/: clk.c gpio.c sci.c retarget.c dma.c intp.c adc.c
  group App
    ../User/App/: main.c app_com.c app_event.c app_lcd.c app_battery.c app_key.c
  group Drv
    ../User/Drv/: drv_task.c drv_timer.c drv_event.c drv_com.c drv_lcd.c drv_battery.c drv_key.c drv_flash.c
  group Hal
    ../User/Hal/: hal_interrupt.c hal_task.c hal_timer.c hal_com.c hal_lcd.c hal_cms32l051.c hal_battery.c hal_key.c hal_flash.c
